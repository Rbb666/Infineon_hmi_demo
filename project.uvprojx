# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: CY8C624ALQI-S2D42:Cortex-M4 Infineon
  pack: Infineon.PSoC6_DFP.1.3.0
  cpu: IRAM(0x08000000,0x00100000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: COMPONENT_CAT1A, RT_USING_LIBC, RT_USING_ARMLIBC, CY_USING_HAL, __CLK_TCK=RT_TICK_PER_SECOND, COMPONENT_BSP_DESIGN_MODUS, __STDC_LIMIT_MACROS, __RTTHREAD__, COMPONENT_CAT1, CY8C624ALQI_S2D42
  c include: packages\LVGL-v8.3.1\src\draw\stm32_dma2d;packages\LVGL-v8.3.1\src\core;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\widgets\calendar;packages\LVGL-v8.3.1\src\extra\others\msg;packages\LVGL-v8.3.1\src\extra\libs\rlottie;packages\LVGL-v8.3.1\src\extra\widgets\list;packages\LVGL-v8.3.1\src\extra\themes\basic;libraries\IFX_PSOC6_HAL\retarget-io;libraries\IFX_PSOC6_HAL\psoc6cm0p;packages\LVGL-v8.3.1\src\hal;rt-thread\include;packages\LVGL-v8.3.1\src\extra\widgets\span;applications\lvgl\demo;packages\LVGL-v8.3.1\src\draw\sdl;packages\LVGL-v8.3.1\src\extra\others\imgfont;packages\LVGL-v8.3.1\src\extra\libs;applications;packages\LVGL-v8.3.1\src\draw;packages\LVGL-v8.3.1\src\extra\libs\freetype;libs\TARGET_RTT-062S2\COMPONENT_BSP_DESIGN_MODUS\GeneratedSource;packages\LVGL-v8.3.1\src\extra\themes\mono;packages\LVGL-v8.3.1\src\extra\widgets\menu;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers;packages\LVGL-v8.3.1\src\extra\widgets\meter;packages\LVGL-v8.3.1\src\extra\others\gridnav;packages\LVGL-v8.3.1\src\extra\widgets;.;packages\LVGL-v8.3.1\src\extra\libs\sjpg;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.1\src\extra\widgets\tileview;packages\LVGL-v8.3.1\src\extra;packages\LVGL-v8.3.1\src\draw\nxp;packages\LVGL-v8.3.1\env_support\rt-thread;libs\TARGET_RTT-062S2;packages\LVGL-v8.3.1\src\extra\layouts\grid;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;packages\LVGL-v8.3.1\src\extra\widgets\spinner;packages\LVGL-v8.3.1\src\extra\libs\fsdrv;packages\LVGL-v8.3.1\src\extra\widgets\spinbox;board;libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;rt-thread\components\libc\posix\io\poll;board\ports;packages\LVGL-v8.3.1\src\draw\swm341_dma2d;libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;packages\LVGL-v8.3.1\src\extra\widgets\tabview;packages\LVGL-v8.3.1\src\extra\widgets\colorwheel;packages\LVGL-v8.3.1\src\draw\nxp\pxp;packages\LVGL-v8.3.1\src\extra\widgets\led;libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;packages\LVGL-v8.3.1\src\font;packages\LVGL-v8.3.1\src;applications\lvgl;packages\LVGL-v8.3.1\src\extra\themes;packages\LVGL-v8.3.1\src\extra\libs\qrcode;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\others;packages\LVGL-v8.3.1\src\extra\layouts\flex;packages\LVGL-v8.3.1\src\extra\layouts;packages\LVGL-v8.3.1\src\extra\others\fragment;rt-thread\components\libc\posix\io\stdio;rt-thread\components\drivers\spi;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;packages\LVGL-v8.3.1\src\draw\nxp\vglite;packages\LVGL-v8.3.1\src\extra\widgets\win;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\others\monkey;libraries\IFX_PSOC6_HAL\capsense;packages\LVGL-v8.3.1\src\extra\libs\png;rt-thread\components\libc\compilers\common\include;packages\ili9341-latest;rt-thread\libcpu\arm\cortex-m4;packages\LVGL-v8.3.1\src\extra\libs\bmp;packages\LVGL-v8.3.1\src\draw\arm2d;packages\LVGL-v8.3.1\src\extra\widgets\animimg;libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;libraries\IFX_PSOC6_HAL\core-lib\include;libraries\HAL_Drivers\config;packages\LVGL-v8.3.1\src\extra\others\ime;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.1\src\extra\others\snapshot;rt-thread\components\finsh;packages\LVGL-v8.3.1\src\draw\sw;packages\LVGL-v8.3.1\src\misc;packages\LVGL-v8.3.1\src\extra\widgets\imgbtn;packages\LVGL-v8.3.1\src\widgets;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.1\src\extra\libs\ffmpeg;packages\LVGL-v8.3.1\src\extra\widgets\keyboard;packages\LVGL-v8.3.1\src\extra\widgets\msgbox;rt-thread\components\drivers\include;packages\LVGL-v8.3.1\src\extra\themes\default;packages\LVGL-v8.3.1\src\extra\libs\gif;packages\LVGL-v8.3.1\src\extra\widgets\chart
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_mdk.S
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_spi.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group ili9341
    packages/ili9341-latest/: lcd_ili9341.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_sysint.c cy_scb_i2c.c cy_gpio.c cy_scb_uart.c cy_scb_common.c cy_prot.c cy_ipc_sema.c cy_ipc_drv.c cy_syslib.c cy_ipc_pipe.c cy_scb_spi.c cy_mcwdt.c cy_sysclk.c cy_systick.c cy_trigmux.c cy_syspm.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_02.c
    libraries/IFX_PSOC6_HAL/retarget-io/: cy_retarget_io.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_scb_common.c cyhal_clock.c cyhal_gpio.c cyhal_system.c cyhal_utils_psoc.c cyhal_utils.c cyhal_hwmgr.c cyhal_lptimer.c cyhal_irq_psoc.c cyhal_syspm.c cyhal_uart.c cyhal_interconnect.c cyhal_spi.c
    libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_02_cm0p_sleep.c psoc6_04_cm0p_sleep.c psoc6_01_cm0p_sleep.c psoc6_03_cm0p_sleep.c
    libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_02_68_qfn.c
    libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
  group libs
    libs/TARGET_RTT-062S2/COMPONENT_BSP_DESIGN_MODUS/GeneratedSource/: cycfg_qspi_memslot.c cycfg.c cycfg_pins.c cycfg_clocks.c cycfg_dmas.c cycfg_routing.c cycfg_system.c cycfg_peripherals.c cycfg_capsense.c cycfg_connectivity_bt.c
    libs/TARGET_RTT-062S2/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_02_cm4.S
    libs/TARGET_RTT-062S2/COMPONENT_CM4/: system_psoc6_cm4.c
    libs/TARGET_RTT-062S2/: cybsp.c
  group LVGL
    packages/LVGL-v8.3.1/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.1/src/draw/sdl/: lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_texture_cache.c lv_draw_sdl_arc.c lv_draw_sdl_utils.c lv_draw_sdl_bg.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_polygon.c lv_draw_sdl.c lv_draw_sdl_rect.c lv_draw_sdl_img.c lv_draw_sdl_stack_blur.c lv_draw_sdl_line.c
    packages/LVGL-v8.3.1/src/draw/: lv_draw_line.c lv_img_buf.c lv_draw_mask.c lv_img_cache.c lv_draw_transform.c lv_img_decoder.c lv_draw_arc.c lv_draw.c lv_draw_rect.c lv_draw_label.c lv_draw_triangle.c lv_draw_layer.c lv_draw_img.c
    packages/LVGL-v8.3.1/src/misc/: lv_area.c lv_anim.c lv_utils.c lv_gc.c lv_txt_ap.c lv_ll.c lv_txt.c lv_log.c lv_timer.c lv_lru.c lv_style_gen.c lv_async.c lv_tlsf.c lv_mem.c lv_bidi.c lv_math.c lv_fs.c lv_printf.c lv_templ.c lv_color.c lv_anim_timeline.c lv_style.c
    packages/LVGL-v8.3.1/src/core/: lv_theme.c lv_obj_draw.c lv_disp.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_style.c lv_obj_class.c lv_obj_scroll.c lv_obj_pos.c lv_obj_tree.c lv_refr.c lv_group.c lv_event.c lv_obj_style_gen.c
    packages/LVGL-v8.3.1/src/widgets/: lv_arc.c lv_label.c lv_textarea.c lv_canvas.c lv_line.c lv_objx_templ.c lv_table.c lv_slider.c lv_btn.c lv_switch.c lv_checkbox.c lv_btnmatrix.c lv_dropdown.c lv_bar.c lv_roller.c lv_img.c
    packages/LVGL-v8.3.1/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.1/src/font/: lv_font_fmt_txt.c lv_font_montserrat_26.c lv_font_montserrat_40.c lv_font_loader.c lv_font_montserrat_30.c lv_font_montserrat_14.c lv_font_montserrat_10.c lv_font_simsun_16_cjk.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_38.c lv_font_montserrat_28_compressed.c lv_font_montserrat_22.c lv_font_montserrat_42.c lv_font_montserrat_36.c lv_font_montserrat_8.c lv_font_montserrat_28.c lv_font_montserrat_44.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_unscii_8.c lv_font.c lv_font_montserrat_12.c lv_font_unscii_16.c lv_font_montserrat_20.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_46.c lv_font_montserrat_12_subpx.c lv_font_montserrat_48.c lv_font_montserrat_24.c
    packages/LVGL-v8.3.1/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.1/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.1/src/extra/libs/fsdrv/: lv_fs_posix.c lv_fs_fatfs.c lv_fs_win32.c lv_fs_stdio.c
    packages/LVGL-v8.3.1/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.1/src/draw/sw/: lv_draw_sw_polygon.c lv_draw_sw_line.c lv_draw_sw.c lv_draw_sw_letter.c lv_draw_sw_gradient.c lv_draw_sw_layer.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw_dither.c lv_draw_sw_blend.c lv_draw_sw_img.c lv_draw_sw_arc.c
    packages/LVGL-v8.3.1/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.1/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.1/src/hal/: lv_hal_tick.c lv_hal_disp.c lv_hal_indev.c
    packages/LVGL-v8.3.1/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_rect.c lv_draw_vglite_blend.c lv_gpu_nxp_vglite.c
    packages/LVGL-v8.3.1/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.1/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.1/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.1/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.1/src/draw/nxp/: lv_gpu_nxp.c
    packages/LVGL-v8.3.1/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    packages/LVGL-v8.3.1/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.1/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.1/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.1/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.1/src/draw/nxp/pxp/: lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.1/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.1/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.1/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.1/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.1/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.1/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.1/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.1/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.1/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.1/src/extra/libs/png/: lv_png.c lodepng.c
    packages/LVGL-v8.3.1/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.1/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-v8.3.1/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.1/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.1/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.1/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.1/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.1/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.1/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.1/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.1/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.1/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.1/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.1/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.1/src/extra/: lv_extra.c
  group LVGL-demo
    applications/lvgl/demo/: lv_demo.c
    packages/lv_music_demo-v0.3.1/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-v0.3.1/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.1/env_support/rt-thread/: lv_rt_thread_port.c
